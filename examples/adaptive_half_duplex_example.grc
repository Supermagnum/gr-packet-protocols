options:
  parameters:
    author: gr-packet-protocols
    category: Packet Protocols
    comment: Half-Duplex Adaptive Modulation System
    description: |-
      Half-duplex adaptive modulation system with TX/RX switching:
      - TX Mode: Source -> Encoder -> Link Quality Monitor -> Adaptive Modulator -> Output
      - RX Mode: Input -> Demodulator -> Decoder -> Link Quality Monitor
      - PTT Control: Switches between TX and RX modes
      - Adaptive Rate Control: Automatically selects modulation mode
      - Modulation Negotiation: Coordinates mode changes between stations
      - KISS TNC: Handles negotiation frames via message ports
      - Quality Feedback: Bidirectional quality metric exchange

      IMPORTANT: Message port connections must be added in generated Python code:
      1. Connect KISS TNC negotiation_out to Modulation Negotiation negotiation_in
      2. Connect Modulation Negotiation to Adaptive Rate Control for mode updates
      3. Setup quality update thread to feed SNR/BER to Link Quality Monitor
      4. Setup periodic quality feedback transmission
      5. Implement PTT control logic to switch between TX/RX modes

      See adaptive_half_duplex_example.py for complete implementation with all connections.
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Half-Duplex Adaptive System
  states: {}

blocks:
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Radio Output (replace with USRP sink for SDR)
    file: /tmp/radio_output.cfile
    type: complex
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    begin_tag: ''
    comment: Radio Input (replace with USRP source for SDR)
    file: /tmp/radio_input.cfile
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: RX Output Sink
    type: byte
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    comment: Control Path Sink (for adaptive_rate_control/modulation_negotiation/kiss_tnc)
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    comment: Null source for RX selector (TX mode)
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: |-
      TX/RX Mode Selector
      Input 0: TX path (adaptive modulator output)
      Input 1: RX path (input from radio)
      Output: Selected path to radio
      NOTE: Control via Python code based on PTT state
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    comment: |-
      RX Input Selector
      Input 0: From radio (RX mode)
      Input 1: Null (TX mode - no RX)
      Output: To demodulator
      NOTE: Control via Python code based on PTT state
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: TX Throttle
    samples_per_second: 9.6k
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: TX Data Source
    repeat: 'True'
    tags: ''
    type: byte
    vector: '[0x48, 0x65, 0x6C, 0x6C, 0x6F, 0x20, 0x57, 0x6F, 0x72, 0x6C, 0x64]'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    comment: RX Demodulator (placeholder - use appropriate demodulator for current mode)
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    comment: RX SNR Estimator
    msg_nsamples: '1000'
    type: '0'
  states: {}
- name: packet_protocols_adaptive_modulator_0
  id: packet_protocols_adaptive_modulator
  parameters:
    comment: 'TX Adaptive Modulator - Default: MODE_2FSK (Bell 202/AX.25 at 1,200 bps) for maximum compatibility and robustness. 2FSK is the most common packet radio mode and provides the best link reliability in poor conditions.'
    enable_adaptation: 'True'
    hysteresis_db: '2.0'
    initial_mode: MODE_2FSK
    samples_per_symbol: '2'
  states: {}
- name: packet_protocols_adaptive_rate_control_0
  id: packet_protocols_adaptive_rate_control
  parameters:
    comment: 'Adaptive Rate Control - selects modulation mode. Default: MODE_2FSK (Bell 202/AX.25 at 1,200 bps) for maximum compatibility and robustness. 2FSK is the most common packet radio mode and provides the best link reliability in poor conditions.'
    enable_adaptation: 'True'
    hysteresis_db: '2.0'
    initial_mode: MODE_2FSK
  states: {}
- name: packet_protocols_ax25_decoder_0
  id: packet_protocols_ax25_decoder
  parameters:
    comment: RX AX.25 Decoder
  states: {}
- name: packet_protocols_ax25_encoder_0
  id: packet_protocols_ax25_encoder
  parameters:
    command_response: 'False'
    comment: TX AX.25 Encoder
    dest_callsign: N1CALL
    dest_ssid: '0'
    digipeaters: ''
    poll_final: 'False'
    src_callsign: N0CALL
    src_ssid: '0'
  states: {}
- name: packet_protocols_kiss_tnc_0
  id: packet_protocols_kiss_tnc
  parameters:
    baud_rate: '9600'
    comment: |-
      KISS TNC - handles negotiation frames via message ports
      NOTE: Connect negotiation_out message port to modulation_negotiation negotiation_in
      in generated Python code
    device: /dev/null
    hardware_flow_control: 'False'
    ptt_enabled: 'True'
    ptt_use_dtr: 'False'
  states: {}
- name: packet_protocols_link_quality_monitor_0
  id: packet_protocols_link_quality_monitor
  parameters:
    alpha: '0.1'
    comment: TX Link Quality Monitor
    update_period: '1000'
  states: {}
- name: packet_protocols_link_quality_monitor_1
  id: packet_protocols_link_quality_monitor
  parameters:
    alpha: '0.1'
    comment: RX Link Quality Monitor
    update_period: '1000'
  states: {}
- name: packet_protocols_modulation_negotiation_0
  id: packet_protocols_modulation_negotiation
  parameters:
    comment: |-
      Modulation Negotiation - coordinates mode changes between stations
      NOTE: Message port connections must be added in Python code
    negotiation_timeout_ms: '5000'
    station_id: N0CALL
    supported_modes: MODE_2FSK,MODE_4FSK,MODE_8FSK,MODE_QPSK
  states: {}

connections:
- [blocks_file_source_1, '0', blocks_selector_1, '0']
- [blocks_null_source_0, '0', blocks_selector_0, '1']
- [blocks_null_source_0, '0', blocks_selector_1, '1']
- [blocks_selector_0, '0', blocks_file_sink_0, '0']
- [blocks_selector_1, '0', digital_gfsk_demod_0, '0']
- [blocks_selector_1, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [blocks_throttle2_0, '0', packet_protocols_ax25_encoder_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [digital_gfsk_demod_0, '0', packet_protocols_ax25_decoder_0, '0']
- [packet_protocols_adaptive_modulator_0, '0', blocks_selector_0, '0']
- [packet_protocols_adaptive_rate_control_0, '0', packet_protocols_modulation_negotiation_0, '0']
- [packet_protocols_ax25_decoder_0, '0', packet_protocols_link_quality_monitor_1, '0']
- [packet_protocols_ax25_encoder_0, '0', packet_protocols_link_quality_monitor_0, '0']
- [packet_protocols_kiss_tnc_0, '0', blocks_null_sink_1, '0']
- [packet_protocols_link_quality_monitor_0, '0', packet_protocols_adaptive_modulator_0, '0']
- [packet_protocols_link_quality_monitor_0, '0', packet_protocols_adaptive_rate_control_0, '0']
- [packet_protocols_link_quality_monitor_1, '0', blocks_null_sink_0, '0']
- [packet_protocols_modulation_negotiation_0, '0', packet_protocols_kiss_tnc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
