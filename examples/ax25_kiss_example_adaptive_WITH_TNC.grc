options:
  parameters:
    author: gr-packet-protocols
    category: Packet Protocols
    comment: AX.25 KISS TNC Example (No Adaptive Modulation)
    description: |-
      Example flowgraph with KISS TNC interface.

      NOTE: Adaptive modulation is NOT included here because:
      - KISS TNC expects BYTE input (packet data)
      - Adaptive Modulator outputs COMPLEX samples (modulated signal)
      - These are incompatible data types

      KISS TNC is designed for hardware TNCs that handle modulation themselves.
      For adaptive modulation, use SDR hardware (USRP, HackRF, etc.) instead.

      If you need adaptive modulation, see:
      - ax25_kiss_example_adaptive_FIXED.grc (uses file sink for SDR)
      - adaptive_speed_example.py (complete Python implementation)
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: AX.25 KISS TNC (No Adaptive)
  states: {}

blocks:
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 9.6k
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Test Data Source
    repeat: 'True'
    tags: ''
    type: byte
    vector: '[0x48, 0x65, 0x6C, 0x6C, 0x6F]'
  states: {}
- name: packet_protocols_ax25_encoder_0
  id: packet_protocols_ax25_encoder
  parameters:
    command_response: 'False'
    comment: AX.25 Encoder
    dest_callsign: N0CALL
    dest_ssid: '0'
    digipeaters: ''
    poll_final: 'False'
    src_callsign: N0CALL
    src_ssid: '0'
  states: {}
- name: packet_protocols_kiss_tnc_0
  id: packet_protocols_kiss_tnc
  parameters:
    baud_rate: '9600'
    comment: |-
      KISS TNC Interface - connects to hardware TNC over serial port

      The hardware TNC handles modulation, so adaptive modulation
      in software is not applicable here.
    device: /dev/null
    hardware_flow_control: 'False'
    ptt_enabled: 'False'
    ptt_use_dtr: 'False'
  states: {}

connections:
- [blocks_throttle2_0, '0', packet_protocols_ax25_encoder_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [packet_protocols_ax25_encoder_0, '0', packet_protocols_kiss_tnc_0, '0']
- [packet_protocols_kiss_tnc_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
