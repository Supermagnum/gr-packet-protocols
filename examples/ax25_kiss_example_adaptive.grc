options:
  parameters:
    author: gr-packet-protocols
    category: Packet Protocols
    comment: AX.25 KISS TNC Example
    description: Example flowgraph demonstrating AX.25 packet encoding with KISS TNC interface and PTT control. Enable PTT control in the KISS TNC block parameters to automatically key/unkey the transmitter during transmission.
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: AX.25 KISS Example
  states: {}

blocks:
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 9.6k
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Test Data Source
    repeat: 'True'
    tags: ''
    type: byte
    vector: '[0, 0, 0]'
  states: {}
- name: packet_protocols_adaptive_modulator_0
  id: packet_protocols_adaptive_modulator
  parameters:
    comment: 'Default: MODE_2FSK (Bell 202/AX.25 at 1,200 bps) for maximum compatibility and robustness. 2FSK is the most common packet radio mode and provides the best link reliability in poor conditions.'
    enable_adaptation: 'True'
    hysteresis_db: '2.0'
    initial_mode: MODE_2FSK
    samples_per_symbol: '2'
  states: {}
- name: packet_protocols_ax25_encoder_0
  id: packet_protocols_ax25_encoder
  parameters:
    command_response: 'False'
    comment: AX.25 Encoder
    dest_callsign: N0CALL
    dest_ssid: '0'
    digipeaters: ''
    poll_final: 'False'
    src_callsign: N0CALL
    src_ssid: '0'
  states: {}
- name: packet_protocols_kiss_tnc_0
  id: packet_protocols_kiss_tnc
  parameters:
    baud_rate: '9600'
    comment: KISS TNC Interface with PTT Control
    device: /dev/null
    hardware_flow_control: 'False'
    ptt_enabled: 'False'
    ptt_use_dtr: 'False'
  states: {}
- name: packet_protocols_link_quality_monitor_0
  id: packet_protocols_link_quality_monitor
  parameters:
    alpha: '0.1'
    update_period: '1000'
  states: {}

connections:
- [blocks_throttle2_0, '0', packet_protocols_ax25_encoder_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [packet_protocols_adaptive_modulator_0, '0', packet_protocols_kiss_tnc_0, '0']
- [packet_protocols_ax25_encoder_0, '0', packet_protocols_link_quality_monitor_0, '0']
- [packet_protocols_kiss_tnc_0, '0', blocks_null_sink_0, '0']
- [packet_protocols_link_quality_monitor_0, '0', packet_protocols_adaptive_modulator_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
