options:
  parameters:
    author: gr-packet-protocols
    category: Packet Protocols
    comment: FX.25 FEC Example
    description: Example flowgraph demonstrating FX.25 Forward Error Correction
    generate_options: qt_gui
    id: top_block
    output_language: python
    samp_rate: '9600'
    title: FX.25 FEC Example
  states: {}

blocks:
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '9600'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Test Data Source
    repeat: 'True'
    tags: ''
    type: byte
    vector: '[0, 0, 0]'
  states: {}
- name: packet_protocols_fx25_decoder_0
  id: packet_protocols_fx25_decoder
  parameters:
    comment: FX.25 Decoder
  states: {}
- name: packet_protocols_fx25_encoder_0
  id: packet_protocols_fx25_encoder
  parameters:
    add_checksum: 'True'
    comment: FX.25 Encoder
    fec_type: '2'
    interleaver_depth: '1'
  states: {}

connections:
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', packet_protocols_fx25_encoder_0, '0']
- [packet_protocols_fx25_decoder_0, '0', blocks_null_sink_0, '0']
- [packet_protocols_fx25_encoder_0, '0', packet_protocols_fx25_decoder_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
