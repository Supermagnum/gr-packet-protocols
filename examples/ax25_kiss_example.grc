options:
  parameters:
    author: gr-packet-protocols
    category: Packet Protocols
    comment: AX.25 KISS TNC Example
    description: Example flowgraph demonstrating AX.25 packet encoding with KISS TNC interface and PTT control. Enable PTT control in the KISS TNC block parameters to automatically key/unkey the transmitter during transmission.
    generate_options: qt_gui
    id: top_block
    output_language: python
    samp_rate: '9600'
    title: AX.25 KISS Example
  states: {}

blocks:
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '9600'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Test Data Source
    repeat: 'True'
    tags: ''
    type: byte
    vector: '[0, 0, 0]'
  states: {}
- name: packet_protocols_ax25_encoder_0
  id: packet_protocols_ax25_encoder
  parameters:
    command_response: 'False'
    comment: AX.25 Encoder
    dest_callsign: N0CALL
    dest_ssid: '0'
    digipeaters: ''
    poll_final: 'False'
    src_callsign: N0CALL
    src_ssid: '0'
  states: {}
- name: packet_protocols_kiss_tnc_0
  id: packet_protocols_kiss_tnc
  parameters:
    baud_rate: '9600'
    comment: KISS TNC Interface with PTT Control
    device: /dev/null
    hardware_flow_control: 'False'
    ptt_enabled: 'False'
    ptt_use_dtr: 'False'
  states: {}

connections:
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', packet_protocols_ax25_encoder_0, '0']
- [packet_protocols_ax25_encoder_0, '0', packet_protocols_kiss_tnc_0, '0']
- [packet_protocols_kiss_tnc_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
