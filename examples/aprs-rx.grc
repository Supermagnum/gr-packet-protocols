options:
  parameters:
    author: gr-packet-protocols
    comment: APRS Receiver for 144.800 MHz
    description: 'APRS Receiver using UHD USRP Source - Frequency: 144.800 MHz - Modulation: Bell 202 (2FSK at 1200 bps) - Protocol: AX.25 - Displays received APRS messages'
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: top_block
    output_language: python
    title: APRS Receiver
  states: {}

blocks:
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: analog_probe_avg_mag_sqrd_x_0
    comment: |-
      RSSI calculation function
      Converts magnitude squared to dB
    function_name: level
    poll_rate: '10'
    value: '0.0'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: RSSI
    type: string
    value: '-100.0 dB'
  states: {}
- name: analog_probe_avg_mag_sqrd_x_0
  id: analog_probe_avg_mag_sqrd_x
  parameters:
    alpha: '0.001'
    comment: |-
      RSSI Probe - measures signal power
      Use level() to get average magnitude squared
    threshold: '0.0'
    type: cf
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: Quadrature Demodulator for FSK
    gain: '1.0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    comment: |-
      Output APRS packets to file
      Messages are written as they are received and processed by Python thread
    file: /tmp/aprs_messages.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    comment: Dummy sink for RSSI probe output
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters:
    comment: Binary Slicer (float to byte, 0 or 1)
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    comment: |-
      Clock Recovery for 1200 baud
      omega = samp_rate / 1200
    gain_mu: '0.175'
    gain_omega: '0.00765625'
    mu: '0.5'
    omega: '166.66666666666666'
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: filter_fft_low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Low-pass filter after quadrature demod
    cutoff_freq: '2400'
    decim: '1'
    gain: '1'
    samp_rate: '200000'
    type: fir_filter_fff
    width: '1200'
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: |-
      Low-pass filter to remove out-of-band noise
      Cutoff: 2400 Hz for Bell 202 (1200 Hz bandwidth)
    cutoff_freq: '2400'
    decim: '1'
    gain: '1'
    samp_rate: '200000'
    type: fir_filter_ccf
    width: '1200'
    win: window.WIN_HAMMING
  states: {}
- name: packet_protocols_ax25_decoder_0
  id: packet_protocols_ax25_decoder
  parameters:
    comment: |-
      AX.25 Decoder
      Expects bit stream (one bit per byte, 0 or 1)
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    label: APRS Messages
    type: string
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '144800000'
    comment: USRP Source - 144.800 MHz
    gain0: '50'
    samp_rate: '400000'
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_probe_avg_mag_sqrd_x_0, '0', blocks_null_sink_1, '0']
- [analog_quadrature_demod_cf_0, '0', filter_fft_low_pass_filter_0, '0']
- [digital_binary_slicer_fb_0, '0', packet_protocols_ax25_decoder_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [filter_fft_low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [filter_fft_low_pass_filter_1, '0', analog_quadrature_demod_cf_0, '0']
- [packet_protocols_ax25_decoder_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', analog_probe_avg_mag_sqrd_x_0, '0']
- [uhd_usrp_source_0, '0', filter_fft_low_pass_filter_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1032-gab049f6e
