options:
  parameters:
    author: gr-packet-protocols
    category: Packet Protocols
    comment: IL2P Example
    description: Example flowgraph demonstrating IL2P (Improved Layer 2 Protocol)
    generate_options: qt_gui
    id: top_block
    output_language: python
    samp_rate: '9600'
    title: IL2P Example
  states: {}

blocks:
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '9600'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Test Data Source
    repeat: 'True'
    tags: ''
    type: byte
    vector: '[0, 0, 0]'
  states: {}
- name: packet_protocols_il2p_decoder_0
  id: packet_protocols_il2p_decoder
  parameters:
    comment: IL2P Decoder
  states: {}
- name: packet_protocols_il2p_encoder_0
  id: packet_protocols_il2p_encoder
  parameters:
    add_checksum: 'True'
    comment: IL2P Encoder
    dest_callsign: N0CALL
    dest_ssid: '0'
    fec_type: '1'
    src_callsign: N0CALL
    src_ssid: '0'
  states: {}

connections:
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', packet_protocols_il2p_encoder_0, '0']
- [packet_protocols_il2p_decoder_0, '0', blocks_null_sink_0, '0']
- [packet_protocols_il2p_encoder_0, '0', packet_protocols_il2p_decoder_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
